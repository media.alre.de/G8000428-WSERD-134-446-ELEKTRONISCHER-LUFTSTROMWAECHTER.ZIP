Properties of the parts of a building model (IFC2X3)

# File
Description: Elektronischer Luftstromwächter für Wandmontage., ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G8000428, Elektronischer Luftstromwächter für Wandmontage.
In: Raum
Description: Der Luftstromwächter WSERD ist für die Überwachung von Ventilatoren, Stellklappen, Befeuchtern und elektrischen Heizregistern gemäß DIN 57100, Teil 420 sowie zum Einsatz mit DDC-Anlagen geeignet. Der Luftstromwächter arbeitet nach dem kalorimetrischen Prinzip. Hierbei wird der Entzug von Wärme durch die Luftströmung gemessen und in den Schaltwert umgerechnet. Der Fühler enthält dazu ein Heizelement und zwei Temperaturfühler. Ein Mikrocontroller steuert die Heizung und misst die Temperaturunterschiede. Aus den hinterlegten Kalibrierkurven berechnet er die Luftströmungsgeschwindigkeit und überträgt den Wert seriell an das Steuergerät. Hier ermittelt ein weiterer Mikrocontroller aus den Vorgabewerten der Einstellregler das Schaltverhalten der beiden Relais. Die Montage erfolgt mit geeigneten Schrauben (nicht im Lieferumfang enthalten) auf ebenen Untergrund und ist lageunabhängig.; Classification: EC011177 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G8000428; ModelLabel: WSERD-134.446; GlobalTradeItemNumber: 4050528075673; ProductURL: https://alre.de/produkt_G8000428
Pset_Specification - NominalLength: 0.136 m; NominalWidth: 0.11 m; NominalDepth: 0.069 m; NetWeight: 0.52
Pset_ALRE_ETIM_Properties - Breite: 136; Höhe: 110; Tiefe: 69; Mit Display: no; Messbereich: 0.2; Explosionsgeschützt: no; Schutzart (IP): IP65; Ausführung Aufnehmer/Fühler: thermisch; Einstecklänge: 165; Max. Spannung der Kontakte: 230; Max. Kontaktbelastung: 8; Differenz verstellbar: yes; Anzahl der Schaltstufen: 10; Ablesbar: no; ETIM-Klasse: EC011177; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G8000428.pdf
